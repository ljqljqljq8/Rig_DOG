## sdkconfig.defaults.lulu-esp32s3
```kconfig
CONFIG_BOARD_TYPE_LULU_ESP32S3=y
CONFIG_LCD_GC9A01_240X240=y
CONFIG_SR_MN_CN_NONE=y
```
